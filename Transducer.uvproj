# Keil uVision project Transducer.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8SB20F64G-QFN24 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Transducer
  c flags: Optimize=8 SizeSpeed=1
  c define: SILABS_RADIO_SI4455 RADIO_DRIVER_EXTENDED_SUPPORT
  c include: C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base
  group Source Group 1
    ./: SILABS_STARTUP.A51 main.c
  group driver
    ./drivers/radio/: radio_comm.c radio_hal.c
    ./drivers/radio/Si4455/: si4455_api_lib.c
